# IAR project Led.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430fn.h
  General.OGChipSelectMenu: MSP430F247 MSP430F247
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDiagSuppress: Pa050
  ICC430.newCCIncludePaths: ..\Scource\hardware; ..\Scource\schdule; ..\Scource\systerm; ..\Scource\algorithm
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f247.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  ICC430.CCDefines: NDEBUG
  ICC430.newCCIncludePaths: ..\Scource\hardware; ..\Scource\schdule; ..\Scource\systerm
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ./: main.c
  group algorithm
    ../Scource/algorithm/: bayes.c bayes.h CFmodels.c CFmodels.h criteria.c criteria.h filter.c filter.h math.c math.h
  group hardware
    ../Scource/hardware/: A7139.c A7139.h A7139_CONFIG.c A7139_CONFIG.h adc.c adc.h digio.c digio.h HMC5983.c HMC5983.h led.c led.h spi.c spi.h
  group schdule
    ../Scource/schdule/: detect.c detect.h interrupt.c interrupt.h join.c join.h mac.c mac.h ProcessEvent.c ProcessEvent.h tdma.c tdma.h
  group system
    ../Scource/systerm/: board.c board.h common.h defs.h delay.c delay.h flash.c flash.h int.c int.h mcu.c mcu.h sys.c sys.h timer.c timer.h types.h uart.c uart.h
