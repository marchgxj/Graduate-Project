# IAR project flash.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430fn.h
  General.OGChipSelectMenu: MSP430F247 MSP430F247
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDiagSuppress: Pa050
  ICC430.newCCIncludePaths: ..\Scource\hardware; ..\Scource\schdule; ..\Scource\systerm; ..\Scource\algorithm
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f247.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: main.c
  group driver
    ../Scource/hardware/: digio.c digio.h led.c led.h
    ../Scource/systerm/: flash.c flash.h mcu.c mcu.h
