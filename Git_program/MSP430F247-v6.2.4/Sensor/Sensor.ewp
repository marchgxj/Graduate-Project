# IAR project Sensor.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430fn.h
  General.OGChipSelectMenu: MSP430F247 MSP430F247
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDiagSuppress: pa050
  ICC430.newCCIncludePaths: ..\Scource\hardware; ..\Scource\schdule; ..\Scource\systerm; ..\Scource\algorithm
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f247.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  ICC430.CCDefines: NDEBUG
  ICC430.newCCIncludePaths: ..\Scource\hardware; ..\Scource\schdule; ..\Scource\systerm
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  group (top)
    ./: main.c
  group hardware
    ../Scource/hardware/: digio.c digio.h led.c led.h PNI.c PNI.h spi.c spi.h
  group system
    ../Scource/systerm/: board.c board.h common.h defs.h delay.c delay.h mcu.c mcu.h sys.c sys.h types.h
