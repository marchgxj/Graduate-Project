# Keil uVision project SPI.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: SPI +hex
  AfterMake: fromelf.exe --bin -o ../obj/SPI.bin ../obj/SPI.axf
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\RTC;..\HARDWARE\RTC;..\HARDWARE\WKUP;..\HARDWARE\ADC;..\HARDWARE\DAC;..\HARDWARE\DMA;..\HARDWARE\IIC;..\HARDWARE\24CXX;..\HARDWARE\SPI;..\HARDWARE\FLASH;..\HARDWARE;..\HARDWARE\A7139;..\HARDWARE\TIMER;..\STM32F10x_FWLib\inc;..\HARDWARE\interrupt;..\trsdata;..\Schdule;..\hardware\Flash
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/TIMER/: timer.c timer.h
    ../HARDWARE/LED/: led.c led.h
    ../HARDWARE/KEY/: key.c key.h
    ../HARDWARE/SPI/: spi.c spi.h
    ../hardware/A7139/: A7139.c A7139.h A7139_CONFIG.c A7139_CONFIG.h
    ../hardware/interrupt/: interrupt.c interrupt.h
    ../hardware/Flash/: flash.c flash.h
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../STM32F10x_FWLib/src/: stm32f10x_exti.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_spi.c
  group main
    ../HARDWARE/: common.h
    ./: main.c
    ../Schdule/: configure.h
  group SCHDULE
    ../Schdule/: beacon.c beacon.h ProcessEvent.c ProcessEvent.h join.c join.h device.c device.h tdma.c tdma.h upload.c upload.h
